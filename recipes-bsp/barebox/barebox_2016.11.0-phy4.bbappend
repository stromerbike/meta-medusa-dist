FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
            file://0001-Fix-linking-with-new-ld,-based-on-u-boot.patch \
"
