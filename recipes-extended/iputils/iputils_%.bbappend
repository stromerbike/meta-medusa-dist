DEPENDS:remove = " gnutls"

SYSTEMD_AUTO_ENABLE:${PN}-rdisc = "disable"
