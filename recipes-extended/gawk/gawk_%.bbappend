do_install:append () {
    rm ${D}${bindir}/gawk-${PV}
}
