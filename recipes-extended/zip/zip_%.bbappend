FILES:zipcloak = "${bindir}/zipcloak"
FILES:zipnote = "${bindir}/zipnote"
FILES:zipsplit = "${bindir}/zipsplit"
PACKAGES =+ "zipcloak zipnote zipsplit"
