DEFAULT_TIMEZONE = "Europe/Zurich"
INSTALL_TIMEZONE_FILE = "0"
