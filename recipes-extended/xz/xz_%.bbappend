inherit update-alternatives

ALTERNATIVE_${PN} = "xz"
ALTERNATIVE_PRIORITY = "100"
