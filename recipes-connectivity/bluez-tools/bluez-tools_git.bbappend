PACKAGECONFIG_remove = " obex"
