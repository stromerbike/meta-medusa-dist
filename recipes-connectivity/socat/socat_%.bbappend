DEPENDS_remove += "openssl"

PACKAGECONFIG[openssl] = "openssl,--disable-openssl,openssl"
