PACKAGECONFIG_remove += "oniguruma"
