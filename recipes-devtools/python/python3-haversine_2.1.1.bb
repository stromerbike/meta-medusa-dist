HOMEPAGE = "https://github.com/mapado/haversine"
SUMMARY = "Calculate the distance between 2 points on Earth."

SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

SRC_URI[md5sum] = "7873520df81cecb7f3ee5034efb52c3e"
SRC_URI[sha256sum] = "60cf0c8c3ba3692c37d0b5fa2d307f74b19cf67bd1dd5f21cb4c1d637a82a615"

inherit setuptools3 pypi
