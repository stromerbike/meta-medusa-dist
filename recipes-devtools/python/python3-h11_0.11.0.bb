HOMEPAGE = "https://github.com/python-hyper/h11"
SUMMARY = "A pure-Python, bring-your-own-I/O implementation of HTTP/1.1"

SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f5501d19c3116f4aaeef89369f458693"

SRC_URI[md5sum] = "12f254d89443b3f3d28b5345876974b8"
SRC_URI[sha256sum] = "3c6c61d69c6f13d41f1b80ab0322f1872702a3ba26e12aa864c928f6a43fbaab"

inherit setuptools3 pypi
