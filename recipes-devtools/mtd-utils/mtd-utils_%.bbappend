PACKAGES =+ "mtd-utils-ubifs-mkfs"
FILES:mtd-utils-ubifs-mkfs = "${sbindir}/mkfs.ubifs"
