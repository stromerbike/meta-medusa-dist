PACKAGECONFIG_remove += "python"
