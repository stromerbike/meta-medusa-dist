PACKAGECONFIG[elfutils] = "--with-elfutils,--without-elfutils,elfutils"
