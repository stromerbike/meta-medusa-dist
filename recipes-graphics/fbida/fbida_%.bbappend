PACKAGECONFIG_remove += "gif"

RDEPENDS_${PN}_remove += "ttf-dejavu-sans-mono"
RDEPENDS_${PN}_append += "ttf-inconsolata"
