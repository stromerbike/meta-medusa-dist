PACKAGECONFIG:remove = " gcrypt gnutls jpeg sdl"
