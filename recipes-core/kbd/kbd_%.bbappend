RDEPENDS:${PN} = "${PN}-consolefonts-cp850"
PACKAGES =+ "${PN}-consolefonts-cp850"
FILES:${PN}-consolefonts-cp850 = "${datadir}/consolefonts/cp850-*.psfu.gz"
