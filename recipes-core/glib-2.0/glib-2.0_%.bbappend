RRECOMMENDS_${PN}_remove = "shared-mime-info"
