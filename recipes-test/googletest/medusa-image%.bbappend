inherit populate_sdk

TOOLCHAIN_TARGET_TASK += "googletest"
