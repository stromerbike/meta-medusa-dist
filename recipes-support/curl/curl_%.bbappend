RRECOMMENDS_lib${BPN} = ""

PACKAGECONFIG_remove += "gnutls"
