# Required by qtbase
PACKAGECONFIG:append = " pcre16"
