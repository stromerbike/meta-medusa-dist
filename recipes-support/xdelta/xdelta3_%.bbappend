PACKAGECONFIG:append = " lzma"
