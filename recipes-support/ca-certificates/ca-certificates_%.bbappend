RDEPENDS:${PN}:remove:class-target = "openssl-bin"
