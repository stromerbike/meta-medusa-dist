inherit populate_sdk_qt5_base

TOOLCHAIN_HOST_TASK += "nativesdk-packagegroup-qt5-toolchain-host"
